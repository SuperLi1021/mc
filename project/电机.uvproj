# Keil uVision project 电机.uvproj, settings and files
target Target 1 (MCS-51)
  device: SN8F5702 SONiX
  cpu: IRAM(0-0xFF) IROM(0-0x0FF5) CLOCK(32000000) DPC
  output: DISPLAY +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: OPTIONS_SN8F5702.A51
  group source
    ./: main.c
    ../user/sys/: display.c sys.c
